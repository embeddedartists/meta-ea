require linux-ea_${PV}.bb
require recipes-kernel/linux/linux-mfgtool.inc
