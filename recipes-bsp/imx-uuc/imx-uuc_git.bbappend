FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Replace-1s-sleep-with-10ms-sleep-to-prevent-occasion.patch"
