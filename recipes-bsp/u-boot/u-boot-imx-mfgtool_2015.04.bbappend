# Copyright (C) 2013-2015 Embedded Artists AB
# Released under the MIT license (see COPYING.MIT for the terms)


FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-adding-EA-COM-boards_2015_04_3.14.52.patch"


